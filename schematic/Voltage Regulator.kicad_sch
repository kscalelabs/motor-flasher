File: schematic/Voltage Regulator.kicad_sch (KiCad schematic)
At the start: 3 parts, among them U3 LD1117S33TR

Commit message: Adding Revisions 2 and 3
Parts:
- renumbered C2 to C1, C1 to C2
